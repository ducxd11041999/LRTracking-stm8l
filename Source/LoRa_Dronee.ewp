# IAR project LoRa_Dronee.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K6 STM8L152K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Lib\src; User\inc; User\src; Lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LoRa_Dronee.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group Lib/inc
    Lib/inc/: stm8l15x.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_it.h stm8l15x_spi.h stm8l15x_usart.h
  group Lib/src
    Lib/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_it.c stm8l15x_spi.c stm8l15x_usart.c
  group User/inc
    User/inc/: Config.h Header.h LoST_Clock.h LoST_EXT.h LoST_GPIO.h LoST_SPI.h Radio.h Radio_Methods.h
  group User/src
    User/src/: LoST_Clock.c LoST_EXT.c LoST_GPIO.c LoST_SPI.c Radio_Methods.c UART.c
